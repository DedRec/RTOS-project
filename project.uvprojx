# Keil uVision project project.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: rmvdk PART_TM4C123GH6PM TARGET_IS_BLIZZARD_RB1
  c include: C:\ti\tivaware
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: automatic.c automatic.h events.c events.h main.c manual.c manual.h utils.c utils.h
    C:/ti/tivaware/driverlib/rvmdk/: driverlib.lib
software components: RTOS:Config 10.0.1, RTOS:Core 10.0.1, RTOS:Heap 10.0.1, CMSIS:CORE 5.5.0, Device:Startup 1.0.1
